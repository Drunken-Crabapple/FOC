# Keil uVision project FOC_QD4310_Keil.uvprojx, settings and files
target FOC_QD4310_Keil (6090000::V6.9::ARMCLANG)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x20007000,0x00001000) IROM(0x08000000,0x00019800) CPUTYPE("Cortex-M4") FPU2 CLOCK(170000000) ELITTLE
  output: FOC_QD4310_Keil +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,SHELL_CFG_USER=\"shell_cfg_user.h\"
  c misc: -std=gnu11 -include sys_public.h -Wno-packed -Wno-dollar-in-identifier-extension
  c include: ..\..\Core\Inc;..\..\Applications\Inc;..\..\BSP;..\..\BSP\retarget;..\..\USB_Device\App;..\..\USB_Device\Target;..\..\UserLib\FOC;..\..\UserLib\FOC\base_classes;..\..\UserLib\QD4310;..\..\UserLib\PID;..\..\UserLib\LetterShell\Inc;..\..\Drivers\STM32G4xx_HAL_Driver\Inc;..\..\Drivers\STM32G4xx_HAL_Driver\Inc\Legacy;..\..\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\..\Drivers\CMSIS\Core\Include;..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc
  scatter file: ..\..\FOC_QD4310_Keil.sct
  group Startup
    ../../: startup_stm32g431xx_keil.s
  group Core
    ../../Core/Src/: adc.c app_freertos.c dma.c fdcan.c gpio.c main.c spi.c stm32g4xx_hal_msp.c stm32g4xx_it.c system_stm32g4xx.c tim.c usart.c
  group USB_Device
    ../../USB_Device/App/: usbd_cdc_if.c usbd_desc.c usb_device.c
    ../../USB_Device/Target/: usbd_conf.c
  group Applications
    ../../Applications/Shell/: ShellPlugs.c StartShell.c
    ../../Applications/Src/: CommunicateTask.c DebugTask.c FOCTask.c
  group BSP
    ../../BSP/: BLDC_Driver_DRV8300.c CurrentSensor_Embed.c Encoder_MT6826S.c Storage_EmbeddedFlash.c
    ../../BSP/retarget/: cdc_tx_buffer.c printf.c retarget.c
  group UserLib/FOC
    ../../UserLib/FOC/: FOC.c
  group UserLib/QD4310
    ../../UserLib/QD4310/: QD4310.c
  group UserLib/LetterShell
    ../../UserLib/LetterShell/Src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_ll_adc.c stm32g4xx_ll_usb.c
  group Middlewares/USB_Device_Library
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
